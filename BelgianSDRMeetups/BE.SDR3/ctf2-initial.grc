options:
  parameters:
    author: jan
    generate_options: qt_gui
    id: ctf2_initial
    output_language: python
    title: ctf2-initial
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1200*10
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jan/Downloads/ctf2_1200bps.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_1, '0']
- [blocks_throttle_1, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
