options:
  parameters:
    author: Kristoff Bonne (on1ARF)
    copyright: gpl-3.0 or newer
    description: rtty decoder for DWD at 147.3 KHz, sends decoded auto to UDP 225.0.0.1/10000 to external baudot decoder
    generate_options: qt_gui
    id: top_block_dwd
    output_language: python
    title: DWD rtty decoder
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '800'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: delay
    orient: Qt.Horizontal
    rangeType: int
    start: '-10'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: demod_baudrate
  id: variable
  parameters:
    value: rtty_baudrate*2
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '42.5'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    orient: Qt.Horizontal
    start: '0'
    step: '1e-5'
    stop: '1'
    value: '0.1'
  states: {}
- name: gainrf
  id: variable
  parameters:
    value: '10'
  states: {}
- name: inselect
  id: variable_qtgui_chooser
  parameters:
    label0: dc block
    label1: no dc block
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: lpfreq
  id: variable_qtgui_range
  parameters:
    label: lpfreq
    orient: Qt.Horizontal
    start: '50'
    step: '1'
    stop: '300'
    value: '100'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rtty_baudrate
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: int(samp_rate/decim/demod_baudrate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 960e3
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '300'
  states: {}
- name: tunefreq
  id: variable_qtgui_range
  parameters:
    label: tunefreq
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/decim/(2*math.pi*fsk_deviation_hz/8.0)
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: capture147_1200sps.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate/decim/demod_baudrate)
    max_iter: '4000'
    scale: 1/(samp_rate/decim/demod_baudrate)
    type: float
  states: {state: bypassed}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samp_per_sym
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: samp_per_sym
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: inselect
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '1e-5'
    init: '0'
    low: '-1e-5'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/800
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 225.0.0.1
    port: '10000'
    psize: '10'
    type: byte
    vlen: '1'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset+tunefreq
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, samp_rate/(2*decim), transition_bw)
    type: ccf
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpfreq
    decim: '1'
    gain: '1'
    samp_rate: 960e3/decim
    type: fir_filter_ccf
    width: lpfreq*1.5
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl_tcp=0,direct_samp=2
    bb_gain0: '10'
    dc_offset_mode0: '2'
    freq0: 147.3e3-freq_offset
    gain0: gainrf
    gain_mode0: 'True'
    if_gain0: '10'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    label5: ''
    nconnections: '5'
    size: '1200'
    srate: samp_rate/decim
    type: float
    ymax: 3e3
    ymin: '-3e3'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decim
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_moving_average_xx_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0_0, '3']
- [analog_quadrature_demod_cf_0, '0', blocks_selector_0, '1']
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '4']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_char_0, '0', blocks_udp_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_delay_0, '0']
- [blocks_moving_average_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_repeat_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_selector_0, '0', analog_agc_xx_0, '0']
- [blocks_threshold_ff_1, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_1, '0', blocks_repeat_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0, '0', blocks_selector_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_repeat_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_threshold_ff_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
